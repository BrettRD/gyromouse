## components/mpu9250/Kconfig
```kconfig
menu "MPU9250"

config AUTO_CONFIG_ADDR
    bool "configure mpu9250 addr at run time"
    default false
    
endmenu
```
